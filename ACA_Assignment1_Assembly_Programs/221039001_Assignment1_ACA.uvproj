# Keil uVision project 221039001_Assignment1_ACA.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: 221039001_Assignment1_ACA
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  group Source Group 1
    ./: add_32_bit.s add_16_bit.s factorial.s square_root.s array_5_32_bit_add.s number_of_zeros_and_ones.s length_of_the_string.s positive_and_negative.s hex_to_ascii_conversion.s factorial_subroutine.s
